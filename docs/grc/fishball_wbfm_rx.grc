options:
  parameters:
    author: Matthieu
    description: WBFM receiver whose channel filtering happens entirely in the FPGA
    generate_options: qt_gui
    id: fishball_wbfm_rx
    output_language: python
    realtime_scheduling: 'On'
    title: Fishball7020 WBFM Receiver (FPGA channelizer)
  states: {}

blocks:
- name: uri
  id: variable
  parameters:
    comment: '192.168.2.1 is the network-over-USB gadget (see the README). Use the board''s RJ45 address instead if you are on wired Ethernet, or usb: for the raw USB backend.'
    value: '''ip:192.168.2.1'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: AD9361 rate. Chosen so the wanted channel lands on exactly Fs/4, which makes the FPGA frequency shift multiplier-free. Do not change this without regenerating the FPGA coefficients.
    value: '4224000'
  states: {}
- name: fpga_decim
  id: variable
  parameters:
    comment: 4224000 / 8 = 528000. Done by rx_fir_decimator in the FPGA.
    value: '8'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: What actually arrives over the link.
    value: int(samp_rate/fpga_decim)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: 528000 / 11 = 48000 exactly, so no resampler is needed anywhere.
    value: '48000'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: int(quad_rate/audio_rate)
  states: {}
- name: lo_offset
  id: variable
  parameters:
    comment: Fs/4 = 1.056 MHz. The AD9361 is tuned this far BELOW the station so its LO leakage and DC offset stay out of the audio; the FPGA shifts the channel back to DC.
    value: int(samp_rate/4)
  states: {}
- name: lo_freq
  id: variable
  parameters:
    comment: What the AD9361 is actually tuned to.
    value: int(station - lo_offset)
  states: {}
- name: station
  id: variable_qtgui_range
  parameters:
    comment: 'Retuning works at runtime: the FPGA filter sits at DC, so it follows the LO. 102.1 = Studio Brussel.'
    gui_hint: 0,0,1,1
    label: Station (Hz)
    start: 87.5e6
    step: 100e3
    stop: 108e6
    value: 102.1e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Used only when gain mode is manual
    gui_hint: 0,1,1,1
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '40'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.3'
  states: {}
- name: squelch_db
  id: variable_qtgui_range
  parameters:
    comment: Set to -100 to disable
    gui_hint: 1,1,1,1
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: force_hardware_rates
  id: snippet
  parameters:
    code: |
      import iio

      # gr-iio programs the AD9361 itself, but the FPGA decimator is a separate IIO
      # device attribute it does not know about - and asking libad9361 for 528 kSPS
      # may make it slow the AD9361 down instead of engaging the FPGA. So set both
      # explicitly, in this order: the converter rate first, then the FPGA
      # decimation that divides it.
      #
      # Writing sampling_frequency on cf-ad9361-lpc is what drives GP_CONTROL bit 0,
      # which selects the filtered path through the bypass mux in the bitstream.
      # WITHOUT THIS THE SAMPLES ARRIVE UNFILTERED.
      def _rate(dev, chan, hz):
          _c = dev.find_channel(chan, False)
          if _c is None:
              raise RuntimeError(f"no input channel {chan} on {dev.name} - wrong firmware?")
          _c.attrs["sampling_frequency"].value = str(int(hz))

      _ctx = iio.Context(self.uri)
      _phy = _ctx.find_device("ad9361-phy")
      _adc = _ctx.find_device("cf-ad9361-lpc")
      if _phy is None or _adc is None:
          raise RuntimeError("ad9361-phy / cf-ad9361-lpc not found at " + str(self.uri))

      _rate(_phy, "voltage0", self.samp_rate)
      _rate(_adc, "voltage0", self.quad_rate)

      # The Fs/4 trick only holds if the converter landed on the rate we asked for.
      _got = int(_phy.find_channel("voltage0", False).attrs["sampling_frequency"].value)
      if abs(_got - int(self.samp_rate)) > 1000:
          print(f"WARNING: asked the AD9361 for {int(self.samp_rate)} Hz, got {_got} Hz.")
          print("         The channel is no longer at exactly Fs/4 and will sit off-centre.")
    comment: 'init_after_blocks, not main_after_init: this runs inside __init__ where the flowgraph is ''self'', straight after gr-iio has built the source and configured the radio, and before start(). If a future gr-iio re-applies its own rates on start(), move this to main_after_start and use tb instead of self.'
    section: init_after_blocks
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '4000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: RF bandwidth is the AD9361 ANALOG filter. It must pass the channel at +1.056 MHz, so it cannot be narrow - but keep it tight enough to spare the ADC from the whole FM band.
    filter_source: '''Auto'''
    frequency: lo_freq
    gain1: '''slow_attack'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: quad_rate
    type: fc32
    uri: uri
  states: {}
- name: qtgui_freq_sink_bb
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: quad_rate
    comment: 'The proof the FPGA is doing its job: one channel filling +/-100 kHz and noise floor either side. Centre frequency reads as the real station frequency, because the FPGA has already shifted the channel to DC.'
    fc: station
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,3,4
    label1: Channel
    name: '"1 - FPGA channelizer output (528 kSPS)"'
    type: complex
    ymax: '-20'
  states: {}
- name: analog_pwr_squelch_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1.0'
    gate: 'False'
    ramp: '0'
    threshold: squelch_db
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    comment: No software channel filter ahead of this block - the FPGA already removed everything outside the channel.
    quad_rate: quad_rate
  states: {}
- name: blocks_multiply_const_volume
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Leave device_name blank for the default. Try "pulse" if silent.
    samp_rate: audio_rate
  states: {}
- name: qtgui_time_sink_audio
  id: qtgui_time_sink_x
  parameters:
    color1: '"dark red"'
    grid: 'True'
    gui_hint: 5,0,2,4
    label1: Audio
    legend: 'False'
    name: '"2 - Demodulated audio"'
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_bb, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_0, '0']
- [analog_pwr_squelch_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_volume, '0']
- [blocks_multiply_const_volume, '0', audio_sink_0, '0']
- [blocks_multiply_const_volume, '0', qtgui_time_sink_audio, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
