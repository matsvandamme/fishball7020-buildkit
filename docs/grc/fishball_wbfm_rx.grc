options:
  parameters:
    author: Matthieu
    description: WBFM receiver for the Fishball7020 SDR, using the FPGA channel filter
    generate_options: qt_gui
    id: fishball_wbfm_rx
    output_language: python
    realtime_scheduling: 'On'
    title: Fishball7020 WBFM Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'Hardware rate. The FPGA FIR scales with this: passband = 0.048 * samp_rate. At 2.304 MSPS that is +/-110 kHz, one WBFM channel.'
    value: '2304000'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: 2304000 / 8 = 288000
    value: '8'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: int(samp_rate/decim)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: 288000 / 6 = 48000 exactly
    value: '48000'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: int(quad_rate/audio_rate)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: FM broadcast band
    gui_hint: 0,0,1,1
    label: Frequency (Hz)
    start: 87.5e6
    step: 100e3
    stop: 108e6
    value: 100.1e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Used only when gain mode is manual
    gui_hint: 0,1,1,1
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '40'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.3'
  states: {}
- name: squelch_db
  id: variable_qtgui_range
  parameters:
    comment: Set to -100 to disable
    gui_hint: 1,1,1,1
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '18000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: RF bandwidth is the AD9361 ANALOG filter - leave it wide. The sharp channel filtering is done by the FPGA FIR.
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''slow_attack'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_rf
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'This view shows the FPGA filter directly: the shoulders at +/-110 kHz are the hardware FIR, not anything GNU Radio is doing.'
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,3,2
    label1: RF
    name: '"1 - Radio output (FPGA filter visible here)"'
    type: complex
    ymax: '-20'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Anti-alias guard for the decimation only. The FPGA already removed everything past ~110 kHz, so this can be gentle.
    cutoff_freq: '100000'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_pwr_squelch_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1.0'
    gate: 'False'
    ramp: '0'
    threshold: squelch_db
    type: complex
  states: {}
- name: qtgui_freq_sink_bb
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: quad_rate
    color1: '"dark green"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,2,3,2
    label1: Baseband
    name: '"2 - Demod input (288 kHz)"'
    type: complex
    ymax: '-20'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    comment: 288000 / 6 = 48000
    quad_rate: quad_rate
  states: {}
- name: blocks_multiply_const_volume
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Leave device_name blank for the default. Try "pulse" if silent.
    samp_rate: audio_rate
  states: {}
- name: qtgui_time_sink_audio
  id: qtgui_time_sink_x
  parameters:
    color1: '"dark red"'
    grid: 'True'
    gui_hint: 5,0,2,4
    label1: Audio
    legend: 'False'
    name: '"3 - Demodulated audio"'
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_rf, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_bb, '0']
- [analog_pwr_squelch_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_volume, '0']
- [blocks_multiply_const_volume, '0', audio_sink_0, '0']
- [blocks_multiply_const_volume, '0', qtgui_time_sink_audio, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
